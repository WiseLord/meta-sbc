FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://fastboot.cfg \
    file://bootmem.cfg \
"
